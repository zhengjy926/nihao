# Keil uVision project nihao.uvprojx, settings and files
target nihao (6230000::V6.23::ARMCLANG)
  device: STM32G474QETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ELITTLE
  output: nihao +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: __ZEPHYR__=1,CORE_CM4,STM32G474xx,USE_FULL_LL_DRIVER,USE_HAL_DRIVER,HSE_VALUE=8000000
  c misc: -imacros ../config_gen/4.5.0/zephyr/autoconf.h
  c include: ..;..\config_gen\4.5.0;..\third_party\zephyr\include;..\third_party\zephyr\arch\common\include;..\third_party\zephyr\soc\st\stm32\stm32g4x;..\third_party\zephyr\soc\st\stm32\common;..\third_party\zephyr\modules\cmsis_6;..\third_party\zephyr\lib\libc\armstdc\include;..\third_party\zephyr\lib\libc\common\include;..\third_party\modules\hal\cmsis_6\CMSIS\Core\Include;..\third_party\modules\hal\stm32\stm32cube\stm32g4xx\soc;..\third_party\modules\hal\stm32\stm32cube\stm32g4xx\drivers\include;..\third_party\modules\hal\stm32\stm32cube\common_ll\include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  scatter file: .\scatter.sct
  link misc: --entry Reset_Handler --remove --diag_suppress L6314W --datacompressor=off
  group board
    ../boards/psg/g474qet6/: startup_stm32g474xx.s
  group system
    ../third_party/modules/hal/stm32/stm32cube/stm32g4xx/soc/: system_stm32g4xx.c
    ../third_party/modules/hal/stm32/stm32cube/stm32g4xx/drivers/src/: stm32g4xx_ll_dma.c stm32g4xx_ll_utils.c
  group app
    ../app/: main.c app.c
  group port
    ../port/src/: rodata_bounds.s init_runner.c errno_shim.c arch_irq_shim.c device_list_bounds.c log_section_bounds.c irq_loader.c kernel_shim.c libc_shim.c hal_shim.c sys_clock_glue.c
  group zephyr/kernel
    ../third_party/zephyr/kernel/: device.c
  group zephyr/drivers
    ../third_party/zephyr/drivers/gpio/: gpio_stm32.c
    ../third_party/zephyr/drivers/led/: led_gpio.c
    ../third_party/zephyr/drivers/pinctrl/: pinctrl_stm32.c common.c
    ../third_party/zephyr/drivers/clock_control/: clock_stm32g4.c clock_stm32_ll_common.c
    ../third_party/zephyr/drivers/interrupt_controller/: intc_gpio_stm32.c intc_exti_stm32.c
    ../third_party/zephyr/drivers/serial/: uart_stm32.c
    ../third_party/zephyr/drivers/console/: uart_console.c
    ../third_party/zephyr/drivers/reset/: reset_stm32.c
    ../third_party/zephyr/drivers/dma/: dma_stm32.c dma_stm32_v2.c dmamux_stm32.c
    ../third_party/zephyr/drivers/timer/: cortex_m_systick.c
  group zephyr/subsys/logging
    ../third_party/zephyr/subsys/logging/: log_core.c log_msg.c log_output.c log_cache.c log_mgmt.c
    ../third_party/zephyr/subsys/logging/backends/: log_backend_uart.c
  group zephyr/lib/os
    ../third_party/zephyr/lib/os/: cbprintf.c cbprintf_complete.c cbprintf_packaged.c printk.c mpsc_pbuf.c
  group zephyr/soc
    ../third_party/zephyr/soc/st/stm32/common/: gpioport_mgr.c
  group zephyr/libc
    ../third_party/zephyr/lib/libc/armstdc/src/: errno.c
